# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx
  ICCARM.CCIncludePath2: $PROJ_DIR$; Debug; settings; ../; ../CMSIS; ../Manual_Config; ../Std_Periph; ../User; ../User/Libraries/ADC_SENSORS_LIB; ../User/Libraries/Finger_Lib/inc; ../User/Libraries/Rifd_lib/Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: settings/stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group CMSIS
    ../CMSIS/: startup_stm32f40xx.s system_stm32f4xx.c
  group Std_Periph
    ../Std_Periph/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User/Libraries/ADC_SENSORS_LIB
    ../User/Libraries/ADC_SENSORS_LIB/: ADC_CONFIG.c
  group User/Libraries/Finger_lib
    ../User/Libraries/Finger_Lib/src/: Delay.c FINGER_MAIN_FUNCTIONS.c Finger_print.c GPIO_CONFIG.c MY_SPI_CONFIG.c UART_Function.c USART_CONFIG.c
  group User/Libraries/Rfid_lib
    ../User/Libraries/Rifd_lib/Src/: mfrc522.c Rfid_main_functions.c
